# Keil uVision project TencentOS_tiny_EVB_G0.uvprojx, settings and files
target TencentOS_Tiny (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G070RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x20008FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: NUCLEO_STM32G070RB +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32G070xx,USE_HAL_DRIVER,STM32G070xx
  c include: ..\..\BSP\Inc;..\..\..\..\platform\vendor_bsp\st\STM32G0xx_HAL_Driver\Inc;..\..\..\..\platform\vendor_bsp\st\STM32G0xx_HAL_Driver\Inc\Legacy;..\..\..\..\platform\vendor_bsp\st\CMSIS\Device\ST\STM32G0xx\Include;..\..\..\..\platform\vendor_bsp\st\CMSIS\Include;..\..\..\..\arch\arm\arm-v7m\common\include;..\..\..\..\arch\arm\arm-v7m\cortex-m0+\armcc;..\..\..\..\kernel\core\include;..\..\..\..\kernel\pm\include;..\..\..\..\kernel\hal\include;..\..\..\..\osal\cmsis_os;..\..\TOS_CONFIG;..\..\..\..\net\at\include;..\..\..\..\net\tencent_firmware_module_wrapper;..\..\..\..\devices\esp8266_tencent_firmware;.\qcloud-iot-sdk-tencent-at-based\include;.\qcloud-iot-sdk-tencent-at-based\src\include;.\user_code;..\..\BSP\Hardware\OLED
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group Application/MDK-ARM
    ./: startup_stm32g070xx.s
  group Application/User
    ../../BSP/Src/: gpio.c main.c mcu_init.c stm32g0xx_hal_msp.c stm32g0xx_it_module.c usart.c adc.c i2c.c spi.c
  group Drivers/STM32G0xx_HAL_Driver
    ../../../../platform/vendor_bsp/st/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_cortex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_exti.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_ll_adc.c stm32g0xx_hal_i2c.c stm32g0xx_hal_i2c_ex.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c
  group Drivers/CMSIS
    ../../BSP/Src/: system_stm32g0xx.c
  group tos/arch
    ../../../../arch/arm/arm-v7m/common/: tos_cpu.c
    ../../../../arch/arm/arm-v7m/cortex-m0+/armcc/: port_c.c port_s.S
  group tos/kernel
    ../../../../kernel/core/: tos_event.c tos_global.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_robin.c tos_sched.c tos_sem.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c tos_binary_heap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_mail_queue.c tos_message_queue.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_stopwatch.c
  group tos/cmsis
    ../../../../osal/cmsis_os/: cmsis_os.c
  group tos/config
    ../../TOS_CONFIG/: tos_config.h
  group hal
    ../../../../platform/hal/st/stm32g0xx/src/: tos_hal_uart.c
  group user_code
    ./qcloud-iot-sdk-tencent-at-based/usr_logic/: data_template_usr_logic.c
    ./user_code/: user_task.c user_hw_init.c encoder.c ws2812_driver.c font_lite.c gui.c arduino_api.c WS2812FX.c
    ../../BSP/Hardware/OLED/: oled.c
  group qcloud-iot-sdk-tencent-at-based
    ./qcloud-iot-sdk-tencent-at-based/port/: hal_at.c hal_os.c
    ./qcloud-iot-sdk-tencent-at-based/src/data_template/: data_template_aciton.c data_template_client.c data_template_client_common.c data_template_client_json.c data_template_client_manager.c data_template_event.c
    ./qcloud-iot-sdk-tencent-at-based/src/module_at/: at_client.c at_log.c at_timer.c at_utils.c iot_device.c module_api_inf.c ringbuff.c
    ./qcloud-iot-sdk-tencent-at-based/src/mqtt/: mqtt.c
    ./qcloud-iot-sdk-tencent-at-based/src/utils/: json_parser.c json_token.c string_utils.c utils_list.c utils_timer.c
software components: CMSIS:CORE 4.3.0
